# KOMPAS-3D part (ZARD 015.320.10.P.m3d)

Model tree:
1. Булева операция:5
2. Булева операция:6  (labels: C:\Program Files\ASCON\KOMPAS-3D V13\Sys\graphic.lyt)

Texts:
  ООО ИК Энерпред-Ярдос